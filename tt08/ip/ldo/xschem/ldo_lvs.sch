v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -30 0 0 {name=l1 author=""}
C {ldo.sym} 590 -280 0 0 {name=X1}
C {devices/noconn.sym} 530 -300 0 0 {name=l2}
C {devices/noconn.sym} 530 -280 0 0 {name=l3}
C {devices/noconn.sym} 530 -260 0 0 {name=l4}
C {devices/noconn.sym} 530 -240 0 0 {name=l5}
C {devices/noconn.sym} 530 -220 0 0 {name=l6}
C {devices/noconn.sym} 650 -300 2 0 {name=l7}
C {devices/noconn.sym} 650 -280 2 0 {name=l8}
